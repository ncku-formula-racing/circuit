# Repository ncku-formula-racing/circuit (continued)

## KiCad design lv-mainboard/lv-mainboard.kicad_pcb (continued)

Board: 2 copper layers, 195.0 x 120.0 mm, 135 parts (36 on the bottom side), 65 nets.

Other parts of the board:
H1#2, H1#3, H2#2, H2#5, H3#2, H3#4, H4#5: MountingHole_Pad; MountingHole_3.2mm_M3_ISO14580_Pad
H1#4, H1#5, H2#3, H3#3, H4#2, H4#4: MountingHole_Pad; MountingHole_3.2mm_M3_ISO7380_Pad
H2#4, H3#5, H4#3: MountingHole_Pad; MountingHole_4.3mm_M4_ISO7380_Pad
kibuzzard-6936E4B2: G***; kibuzzard-6936E4B2
kibuzzard-6936E50D: G***; kibuzzard-6936E50D
kibuzzard-69454A4D: G***; kibuzzard-69454A4D
kibuzzard-69454B20: G***; kibuzzard-69454B20
kibuzzard-69454C2F: G***; kibuzzard-69454C2F
kibuzzard-6945460C: G***; kibuzzard-6945460C
kibuzzard-6945462F: G***; kibuzzard-6945462F
kibuzzard-69454637: G***; kibuzzard-69454637
kibuzzard-69454910: G***; kibuzzard-69454910
kibuzzard-69455236: G***; kibuzzard-69455236

Their connections:
GND: H1#2.1, H1#3.1, H1#4.1, H1#5.1, H2#2.1, H2#3.1, H2#4.1, H2#5.1, H3#2.1, H3#3.1, H3#4.1, H3#5.1, H4#2.1, H4#3.1, H4#4.1, H4#5.1; also elsewhere on the board

## KiCad design lv_mainboard/lv_mainboard.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole_Pad; MountingHole_4.3mm_M4_ISO7380_Pad
H5, H6, H7, H8, H9, H10, H11, H12, H13, H14, H15, H16, H17, H18, H19, H20, H21, H22, H23, H24: MountingHole_Pad; MountingHole_3.2mm_M3_ISO7380_Pad
J1, J18, J20, J21, J22: Conn_01x02; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2, J6, J7, J13: Conn_02x10_Odd_Even; PinSocket_2x10_P2.54mm_Vertical
J3, J23: Conn_01x03; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J4, J8, J12, J14, J16, J25, J26, J27: Conn_01x04; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J5: Conn_01x05; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J9, J10, J15, J19, J24: PWR; AMASS_XT60-M_1x02_P7.20mm_Vertical
J11: Conn_02x05_Counter_Clockwise; PinSocket_2x05_P2.54mm_Vertical
R1, R2: R; R_0603_1608Metric

Connections:
+24V: J8.4, J24.1
BMS_FAULT: J2.4, J4.3, J6.10
BMS_LED: J6.9, J14.2, J26.2
BMS_RST: J6.11, J14.3, J26.3
BSE_L_Fault: J2.10, J7.6
BSE_L_init: J7.2, J21.2, R1.2
BSE_R_Fault: J2.12, J7.10
BSE_R_init: J7.4, J21.1, R2.2
BSPD: J2.8, J6.16, J7.18, J7.20
BSPD_LED: J6.20, J12.2, J25.2
BSPD_RST: J6.18, J12.3, J25.3
BSPD_signal3: J2.14, J7.14
BSPD_signal4: J2.7, J7.16
CAN+: J2.20, J13.20, J20.1, J22.1
CAN-: J2.18, J13.18, J20.2, J22.2
FAN_PWM: J13.4, J23.2
FAN_PWR: J3.3, J13.9
GND: H1.1, H2.1, H3.1, H4.1, H5.1, H6.1, H7.1, H8.1, H9.1, H10.1, H11.1, H12.1, H13.1, H14.1, H15.1, H16.1, H17.1, H18.1, H19.1, H20.1, H21.1, H22.1, H23.1, H24.1, J1.1, J2.15, J2.17, J2.19, J3.1, J4.1, J5.1, J6.2, J6.6, J6.8, J6.15, J6.19, J7.5, J7.7, J7.9, J7.11, J7.13, J7.15, J7.17, J8.1, J9.2, J10.2, J11.9, J12.1, J13.15, J13.17, J13.19, J14.1, J15.2, J16.1, J18.1, J19.2, J23.1, J24.2, J25.1, J26.1, J27.1, R1.1, R2.1; also elsewhere on the board
IMD_FAULT: J2.6, J4.4, J6.13
IMD_LED: J6.14, J16.2, J27.2
IMD_RST: J6.12, J16.3, J27.3
P1_DAQ: J11.2, J13.1, J13.3, J13.5
P2_BSPD: J7.1, J7.3, J11.1
P3_SDCPCB: J6.1, J6.3, J6.17, J11.4
P4_HVbox: J9.1, J11.3
P5_MCU: J2.1, J2.3, J2.5, J11.6
P6_sideboard: J11.5, J12.4, J14.4, J16.4, J25.4, J26.4, J27.4
P7_ACC: J11.8, J18.2
P8: J11.7, J15.1; also elsewhere on the board
P9: J11.10, J19.1
PT_signal: J5.4, J13.8
PUMP_PWM: J13.6, J23.3
PUMP_PWR: J3.2, J13.7
SDC_OUT: J6.4, J10.1; also elsewhere on the board
SWDCLK: J2.11
SWDIO: J2.13
SW_Fault: J2.2, J6.7
SYS_JTCK-SWCLK: J13.10
SYS_JTMS-SWDIO: J13.12
TIM1_CH1: J5.3, J13.13
TSAL: J4.2, J8.2
TSSI: J2.16, J8.3
USART1: J5.2, J13.16
USART2: J5.5, J13.2
current_init: J1.2, J7.19

Notes on the sheet:
P1:DAQ P2:BSPD P3:SDC P4:HVbox P5:MCU、lv mainboard P6:LED button(LED) P7:to ACC P8:x P9:control board
SDC out
Fuse + PWR
SDC
24V to lv board(TSSI、RTML) fuse box 的走在上面
PWR 24V
rear MCU
sideboard
DAQ
from ACC box
PWM
BSPD
To mainhoop light

Board: 2 copper layers, 140.0 x 220.0 mm, 78 parts (0 on the bottom side), 41 nets.

Other parts of the board:
J10#2, J15#2: PWR; AMASS_XT60-M_1x02_P7.20mm_Vertical
kibuzzard-688F5F64: G***; kibuzzard-688F5F64
kibuzzard-688F6DC2: G***; kibuzzard-688F6DC2
kibuzzard-688F63AA: G***; kibuzzard-688F63AA
kibuzzard-688F63D0: G***; kibuzzard-688F63D0
kibuzzard-688F64B0: G***; kibuzzard-688F64B0
kibuzzard-688F64BC: G***; kibuzzard-688F64BC
kibuzzard-688F64C5: G***; kibuzzard-688F64C5
kibuzzard-688F605D: G***; kibuzzard-688F605D
kibuzzard-688F607C: G***; kibuzzard-688F607C
kibuzzard-688F632C: G***; kibuzzard-688F632C
kibuzzard-688F638D: G***; kibuzzard-688F638D
kibuzzard-688F662E: G***; kibuzzard-688F662E
kibuzzard-688F668F: G***; kibuzzard-688F668F
kibuzzard-688F6027, kibuzzard-688F6027#2: G***; kibuzzard-688F6027
kibuzzard-688F6048: G***; kibuzzard-688F6048
kibuzzard-688F6344: G***; kibuzzard-688F6344
kibuzzard-688F6381: G***; kibuzzard-688F6381
kibuzzard-688F6407: G***; kibuzzard-688F6407
kibuzzard-688F6412: G***; kibuzzard-688F6412
kibuzzard-688F6425, kibuzzard-688F6425#2: G***; kibuzzard-688F6425
kibuzzard-688F6442: G***; kibuzzard-688F6442
kibuzzard-688F6465: G***; kibuzzard-688F6465

Their connections:
GND: J10#2.2, J15#2.2; also elsewhere on the board
P8: J15#2.1; also elsewhere on the board
SDC_OUT: J10#2.1; also elsewhere on the board
